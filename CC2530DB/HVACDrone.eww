<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HVACDrone.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>HVACDrone</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>HVACDrone</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>HVACDrone</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>HVACDrone</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


